options:
  parameters:
    author: DannyNavarro_SebastianRoman
    copyright: UIS
    generate_options: qt_gui
    id: Practica1_labComu2_Grupo6
    output_language: python
    title: Practica Conociendo USRP
  states: {}

blocks:
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Frecuencia Portadora
    start: 50e6
    step: 1e6
    stop: 2200e6
    value: 110e6
  states: {}
- name: GTx
  id: variable_qtgui_range
  parameters:
    label: Ganancia Tx
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: N0
  id: variable_qtgui_range
  parameters:
    label: Amplitud Ruido
    start: '1e-6'
    step: '1e-6'
    stop: '500e-3'
    value: '250e-3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 12.5e6
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: N0
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: Fc
    gain0: GTx
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
